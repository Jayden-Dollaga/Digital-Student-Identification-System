#include "ClassicAdapter.h"

#include <string.h>

static const byte RFID_KEY_CANDIDATES[][6] = {
  {0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF},
  {0xD3, 0xF7, 0xD3, 0xF7, 0xD3, 0xF7},
  {0xA0, 0xA1, 0xA2, 0xA3, 0xA4, 0xA5},
  {0xB0, 0xB1, 0xB2, 0xB3, 0xB4, 0xB5},
  {0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  {0xA1, 0xA2, 0xA3, 0xA4, 0xA5, 0xA6},
  {0xB1, 0xB2, 0xB3, 0xB4, 0xB5, 0xB6},
  {0x4D, 0x3A, 0x99, 0xC3, 0x51, 0xDD},
  {0x1A, 0x98, 0x2C, 0x7E, 0x45, 0x9A},
  {0xAA, 0xBB, 0xCC, 0xDD, 0xEE, 0xFF},
  {0x71, 0x4C, 0x5C, 0x88, 0x6E, 0x97},
  {0x58, 0x7E, 0xE5, 0xF9, 0x35, 0x0F},
  {0xA0, 0x47, 0x8C, 0xC3, 0x90, 0x91},
  {0x53, 0x3C, 0xB6, 0xC7, 0x23, 0xF6},
  {0x89, 0xEC, 0xA9, 0x40, 0x0E, 0xB1},
  {0x5C, 0x59, 0x87, 0x2F, 0x54, 0xC2},
  {0xE9, 0x64, 0x24, 0x9A, 0xEE, 0x8A},
  {0x00, 0x01, 0x02, 0x03, 0x04, 0x05},
  {0x01, 0x01, 0x01, 0x01, 0x01, 0x01},
  {0x11, 0x11, 0x11, 0x11, 0x11, 0x11},
  {0x12, 0x34, 0x56, 0x78, 0x90, 0xAB},
  {0x12, 0x34, 0x56, 0xAB, 0xCD, 0xEF},
  {0x00, 0x00, 0x00, 0x00, 0x00, 0x01},
  {0x00, 0x00, 0x00, 0x00, 0x00, 0xFF},
  {0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00},
  {0xA6, 0x2A, 0x24, 0x88, 0x6C, 0x08},
  {0xE2, 0x50, 0x9C, 0x1D, 0x23, 0x14},
  {0x1B, 0x33, 0x99, 0x33, 0x33, 0x33},
  {0x51, 0x93, 0x63, 0x45, 0x9A, 0x0D},
  {0xD0, 0x1A, 0xFC, 0x9E, 0x63, 0x8F},
  {0x8F, 0xD0, 0xA4, 0xF2, 0x56, 0xE9},
  {0xC0, 0x86, 0x6D, 0x8D, 0x9C, 0xC7},
  {0x25, 0x99, 0x36, 0x20, 0x42, 0xAB},
  {0x64, 0x80, 0x60, 0x71, 0x28, 0x82},
  {0x49, 0x39, 0x4E, 0x4A, 0x62, 0x20},
  {0x69, 0x41, 0xAE, 0x24, 0x1D, 0x9D},
  {0xEC, 0x00, 0x6A, 0xCB, 0x8F, 0x31},
  {0xB5, 0xFF, 0x67, 0xCB, 0xA9, 0x51},
  {0xEE, 0x0A, 0xC1, 0x2C, 0xE5, 0x1E},
  {0x36, 0x90, 0xF5, 0x28, 0xE9, 0x3A},
  {0x90, 0xC3, 0x1F, 0xF1, 0x9A, 0xE7},
  {0xF1, 0x24, 0xC2, 0x63, 0x8C, 0xD9},
  {0x8A, 0x19, 0x9F, 0x6C, 0xAF, 0xDA},
  {0x8F, 0x79, 0x9A, 0x27, 0x8A, 0xE4},
  {0x2A, 0x2C, 0x13, 0xCC, 0x24, 0x2A},
  {0x77, 0x77, 0x77, 0x77, 0x77, 0x77},
  {0x99, 0x99, 0x99, 0x99, 0x99, 0x99},
  {0x12, 0x12, 0x12, 0x12, 0x12, 0x12},
  {0x0B, 0x0B, 0x0B, 0x0B, 0x0B, 0x0B},
  {0x4F, 0x45, 0x4E, 0x44, 0x45, 0x54},
};

static const byte RFID_KEY_CANDIDATE_COUNT =
    sizeof(RFID_KEY_CANDIDATES) / sizeof(RFID_KEY_CANDIDATES[0]);

byte classicKeyCandidateCount() {
  return RFID_KEY_CANDIDATE_COUNT;
}

const byte *classicKeyCandidate(byte index) {
  if (index >= RFID_KEY_CANDIDATE_COUNT) return nullptr;
  return RFID_KEY_CANDIDATES[index];
}

static bool sameUid(const MFRC522::Uid &left, const MFRC522::Uid &right) {
  if (left.size != right.size) return false;
  for (byte i = 0; i < left.size; i++) {
    if (left.uidByte[i] != right.uidByte[i]) return false;
  }
  return true;
}

bool authenticateClassicCard(
    MFRC522 &reader,
    MFRC522::MIFARE_Key &activeKey,
    byte block,
    int *matchedIndex) {
  const MFRC522::Uid originalUid = reader.uid;
  for (byte index = 0; index < RFID_KEY_CANDIDATE_COUNT; index++) {
    memcpy(activeKey.keyByte, RFID_KEY_CANDIDATES[index], MFRC522::MF_KEY_SIZE);
    MFRC522::StatusCode status = reader.PCD_Authenticate(
        MFRC522::PICC_CMD_MF_AUTH_KEY_A, block, &activeKey, &reader.uid);
    if (status == MFRC522::STATUS_OK) {
      if (matchedIndex) *matchedIndex = index;
      return true;
    }

    reader.PICC_HaltA();
    reader.PCD_StopCrypto1();
    if (index + 1 < RFID_KEY_CANDIDATE_COUNT) {
      byte atqa[2];
      byte atqaSize = sizeof(atqa);
      MFRC522::StatusCode wakeStatus = reader.PICC_WakeupA(atqa, &atqaSize);
      if ((wakeStatus != MFRC522::STATUS_OK && wakeStatus != MFRC522::STATUS_COLLISION) ||
          !reader.PICC_ReadCardSerial() || !sameUid(reader.uid, originalUid)) {
        break;
      }
    }
  }
  if (matchedIndex) *matchedIndex = -1;
  return false;
}

bool readClassicPayload(MFRC522 &reader, byte firstBlock, byte payload[48]) {
  for (byte offset = 0; offset < 3; offset++) {
    byte blockBuffer[18];
    byte bufferSize = sizeof(blockBuffer);
    if (reader.MIFARE_Read(firstBlock + offset, blockBuffer, &bufferSize) != MFRC522::STATUS_OK) {
      return false;
    }
    memcpy(payload + offset * 16, blockBuffer, 16);
  }
  return true;
}

bool writeClassicPayload(MFRC522 &reader, byte firstBlock, const byte payload[48]) {
  for (byte offset = 0; offset < 3; offset++) {
    byte *blockData = const_cast<byte *>(payload + offset * 16);
    if (reader.MIFARE_Write(firstBlock + offset, blockData, 16) != MFRC522::STATUS_OK) {
      return false;
    }

    byte verifyBuffer[18];
    byte verifySize = sizeof(verifyBuffer);
    if (reader.MIFARE_Read(firstBlock + offset, verifyBuffer, &verifySize) != MFRC522::STATUS_OK ||
        memcmp(payload + offset * 16, verifyBuffer, 16) != 0) {
      return false;
    }
  }
  return true;
}
